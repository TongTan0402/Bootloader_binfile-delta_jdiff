# Keil uVision project bootloader_binfile.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_binfile
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./Resources/main/: iwdg.c iwdg.h main.c sys.c sys.h
  group bootloader
    ./Resources/bootloader/: flash.c flash.h fsm.c fsm.h uart.c uart.h jump_to_app.c jump_to_app.h
  group spi_sdcard
    ./Resources/spi_sdcard/: sdcard.c sdcard.h spi.c spi.h
  group fatfs
    ./Resources/spi_sdcard/fatfs/: ccsbcs.c diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group xdelta
    ./Resources/xdelta/: delta.c delta.h janpatch.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
